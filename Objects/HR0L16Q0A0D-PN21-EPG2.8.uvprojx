# Keil uVision project HR0L16Q0A0D-PN21-EPG2.8.uvprojx, settings and files
target HR0L16Q0A0D-PN21-EPG2.8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HR0L16Q0A0D-PN21-EPG2.8 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\main;..\Soft_layer;..\Hardware;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport\startup;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f051.s
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_misc.c stm32f0xx_exti.c stm32f0xx_syscfg.c
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f0xx.c
  group Hardware
    ../Hardware/: Hardware.c Hardware_GPIO.c Hardware_NVIC.c Hardware_RCC.c Hardware_timer.c Hardware_usart.c Hardware_EXTI.c Hardware_systick.c
  group Soft_layer
    ../Soft_layer/: Soft_layer.c Soft_layer_bus.c Soft_layer_crc16.c Soft_layer_flash.c Soft_layer_IO_input.c Soft_layer_rs485.c
  group main
    ../main/: main.c stm32f0xx_it.c
